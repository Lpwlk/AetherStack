File: AetherFC/AetherFC.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Repo cleaned up before ESC schematics
Other:
- company: (none) -> https://github.com/Lpwlk/AetherStack
